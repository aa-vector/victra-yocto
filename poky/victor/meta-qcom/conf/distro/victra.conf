## poky/victor/meta-qcom/conf/distro/victra.conf
```bitbake
BASEDISTRO ?= "msm-perf"
require conf/distro/msm-perf.conf

DISTRO_NAME = "victra"
DISTROOVERRIDES =. "victra:"

PRODUCT ?= "robot"
```
